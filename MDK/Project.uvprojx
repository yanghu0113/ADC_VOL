# Keil uVision project Project.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CW32F003F4 PS
  pack: PS.CW32F003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  link misc: --keep=*Handler
  group Startup
    ../: startup_cw32f003.s
  group User
    ../USER/src/: main.c interrupts_cw32f003.c uart_driver.c pwm_driver.c adc_driver.c ac_measurement.c charging_sm.c contactor_control.c cp_signal.c pp_signal.c ui_display.c hlw_uart_driver.c spi_oled_driver.c error_handler.c
  group Driver
    ../Libraries/src/: cw32f003_adc.c cw32f003_atim.c cw32f003_awt.c cw32f003_btim.c cw32f003_crc.c cw32f003_debug.c cw32f003_digitalsign.c cw32f003_flash.c cw32f003_gpio.c cw32f003_gtim.c cw32f003_i2c.c cw32f003_iwdt.c cw32f003_lvd.c cw32f003_pwr.c cw32f003_ram.c cw32f003_rcc.c cw32f003_spi.c cw32f003_systick.c cw32f003_uart.c cw32f003_vc.c cw32f003_wwdt.c system_cw32f003.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
